# Keil uVision project led.uvprojx, settings and files
target led (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: -fgnu
  c include: ..\Libraries\CMSIS;..\Libraries\inc;..\User;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\timing;..\SYSTEM\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_dma.c misc.c
  group User
    ../User/: main.c stm32f10x_conf.h bsp_st7789.c bsp_st7789.h app_config.h lcd_dma.c lcd_dma.h key_driver.c key_driver.h ui_event.c ui_event.h ui_types.h ui_dirty.c ui_dirty.h ui_anim.c ui_anim.h ui_feedback.c ui_feedback.h ui_font.c ui_font.h ui_draw.c ui_draw.h ui_renderer.c ui_renderer.h ui_page.c ui_page.h page_home.c page_home.h game_2048.c game_2048.h game_snake.c game_snake.h page_game.c page_game.h page_pause.c page_pause.h page_snake.c page_snake.h page_settings.c page_settings.h page_info.c page_info.h app_ui.c app_ui.h
  group SYS
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.h
    ../SYSTEM/timing/: timing.c timing.h
